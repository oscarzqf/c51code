# Keil uVision project 蓝牙小车2.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 蓝牙小车2.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: smart car 2.0 .c
