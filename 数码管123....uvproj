# Keil uVision project 数码管123....uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 数码管123... +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: shuamaguan123.c
