# Keil uVision project OLEDgame.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: OLEDgame
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./OLED_Dino-master/: dino.c I2C.c main.c OLED.c
